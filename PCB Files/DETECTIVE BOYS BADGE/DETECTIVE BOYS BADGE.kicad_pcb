# Repository DanieElectronics/DetectiveBoysWT

File README.md:

# Detective Boys walkie talkie pin badge
Walkie talkie radio pin badge inspired by Detective Conan anime series using a custom PCB and an ATMEGA328P (Arduino) microcontroller.		
Integrated rechargable battery, can be charged using any USB-C cable and USB power supply.

This repository includes the fabrication files for mounting the boards and assembling the components (gerber files, bill of materials, pick and place), as long as the code used for the microcontroller.
Keep in mind there are external components to be mounted/soldered as the battery or radio module.

## How to use
To use the walkie talkie plug any headphones with microphone into the 3.5mm audio jack, then flick the switch on the left side of the board and the LED will light up.
Press and hold the button on the board to transmit audio, all the near walkie talkies will receive and play the audio.
No pairing or previous configuration is needed.

The battery lasts around 4 hours and it can be recharged by plugging an USB-C cable, any cable or power source is compatible.
When the battery is charging, the LED near the USB connector will light up, when the battery is fully charged the LED will turn off again.
The headphones used may affect on the audio quality, try using different headphones to compare the results.

## Technical description
This project uses ATMEGA328P microcontroller on a custom PCB, the microcontrollers sends the audio data using NRF24L01 radio modules,
ATMEGA328P microcontroller works at 3.3V 8MHz, you can program it using Arduino IDE and an external programmer like USBTinyISP.

The NRF24L01 radio module is a SMD version suitable for small sized boards, it has a maximum range of 100 meters.

The LiPo battery is directly soldered into the battery terminals of the board, recommended capacity is 100-150mAh.

## KiCad design PCB Files/DETECTIVE BOYS BADGE/DETECTIVE BOYS BADGE.kicad_pcb

Parts:
BT1: LiPo 100mAh; PinSocket_1x02_P2.54mm_Vertical
C1, C2, C4, C5, C6, C8: 10uF; C_0805_2012Metric
C3, C10, C11: 100nF; C_0805_2012Metric
C7, C9: 330nF; C_0805_2012Metric
D1, D2: LED_0805; LED_0805_2012Metric
J1: Jack 3.5mm; Jack_3.5mm_PJ320D_Horizontal
J2: ICSP; Molex_200528-0050_1x05-1MP_P1.00mm_Horizontal
R1, R5, R6: 330; R_0805_2012Metric
R2, R3: 5.1k; R_0805_2012Metric
R4, R10: 1k; R_0805_2012Metric
R7, R8, R9, R11, R12, R13: 10k; R_0805_2012Metric
RG1: 470k; R_0805_2012Metric
SW1: SPDT_PCM12; SW_SPDT_PCM12
SW2: Pushbutton; SW_SPST_PTS645
U1: NRF24L01_Breakout; NRF24L01_Mini
U2: MIC5205-3.3YM5; SOT-23-5
U3: TP4056; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U4: LM358; SOP-8_3.9x4.9mm_P1.27mm
U5: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
USB1: USB_C 31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12
X1: Resonator 8MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C1.1, C4.1, C10.2, C11.2, R8.1, R9.2, R13.1, U1.2 (VCC), U2.5 (OUT), U4.8 (V+), U5.4 (VCC), U5.6 (VCC), U5.18 (AVCC)
/SPK_L: C7.2, C9.2, J1.T, R6.2
/SPK_R: C7.1, C9.1, J1.R1, R5.1
/VIN: C2.1, D1.2 (A), SW1.2 (B), U2.1 (IN), U2.3 (EN)
A0: RG1.1, U4.1, U5.23 (PC0)
A1: SW2.2, U5.24 (PC1)
AUDIO_L: R6.1, U5.13 (PB1)
AUDIO_R: R5.2, U5.14 (PB2)
BAT: BT1.1 (+), C6.1, SW1.1 (A), U3.5 (BAT)
CE: U1.3 (CE), U5.11 (PD7)
CSN: U1.4 (~CSN), U5.12 (PB0)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C10.1, C11.1, J1.R2, J2.5, R1.2, R2.2, R3.2, R7.2, R11.1, R12.1, SW2.1, U1.1 (GND), U2.2 (GND), U3.3 (GND), U3.9 (EP), U4.4 (V-), U5.3 (GND), U5.5 (GND), U5.21 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.S1 (SHIELD), X1.2
MIC: C8.1, J1.S, R8.2
MISO: J2.2, U1.7 (MISO), U5.16 (PB4)
MOSI: J2.3, U1.6 (MOSI), U5.15 (PB3)
unnamed: C8.2, R10.2
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R4.1
unnamed: R2.1, USB1.A5 (CC1)
unnamed: R3.1, USB1.B5 (CC2)
unnamed: R4.2, U3.7 (CHRG)
unnamed: R7.1, U3.2 (PROG)
unnamed: R10.1, RG1.2, U4.2 (-)
unnamed: R9.1, R11.2, R12.2, U4.3 (+)
RESET: J2.4, R13.2, U5.29 (~RESET/PC6)
SCK: J2.1, U1.5 (SCK), U5.17 (PB5)
VBUS: C3.1, C5.1, D2.2 (A), U3.4 (VCC), U3.8 (CE), USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
XTAL1: U5.7 (XTAL1/PB6), X1.1
XTAL2: U5.8 (XTAL2/PB7), X1.3

Notes on the sheet:
Battery charger
Audio imput amplifier
Mandatory low pass filter. Using R=330 and C=330n sets cutoff frequency at 1.4kHz Filters pwm high frequency and allows human voice frequencies
I/O
RG1 sets gain for microphone (Gain = RG1/1000) Typical gain for a headphone mic is 470 For capsule microphone values might be lower around 100
Radio communication
Microcontroller ATMEGA328P 3.3v 8MHz
Audio output
Detective Boys walkie talkie v1.1 (28/06/2022)
Voltage regulator

Board: 2 copper layers, 45.9 x 55.0 mm, 39 parts (0 on the bottom side), 29 nets.

File PCB Files/DETECTIVE BOYS BADGE/fabrication/BILL OF MATERIALS v1.1.csv:

Id;Designator;Package;Quantity;Designation;LCSC Ref
1;C6,C5,C2,C1,C4,C8;C_0805_2012Metric;6;10uF;C17024
2;R9,R13,R8,R7,R11,R12;R_0805_2012Metric;6;10k;C17414
3;J1;Jack_3.5mm_PJ320D_Horizontal;1;Jack 3.5mm;C521460
4;SW2;SW_SPST_PTS645;1;Pushbutton;C221871
5;D1,D2;LED_0805_2012Metric;2;LED_0805;C434431
6;C11,C3,C10;C_0805_2012Metric;3;100nF;C476766
7;U1;NRF24L01_Mini;1;NRF24L01_Breakout;N/A
8;U4;SOP-8_3.9x4.9mm_P1.27mm;1;LM358;C7950
9;SW1;SW_SPDT_PCM12;1;SPDT_PCM12;C221841
10;R6,R5,R1;R_0805_2012Metric;3;330;C25306
11;RG1;R_0805_2012Metric;1;470k;C17709
12;U5;TQFP-32_7x7mm_P0.8mm;1;ATmega328P-AU;C14877
13;BT1;PinSocket_1x02_P2.54mm_Vertical;1;LiPo 100mAh;N/A
14;R10,R4;R_0805_2012Metric;2;1k;C115316
15;USB1;USB_C_Receptacle_HRO_TYPE-C-31-M-12;1;USB_C 31-M-12;C165948
16;R3,R2;R_0805_2012Metric;2;5.1k;C27834
17;X1;Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm;1;Resonator 8MHz;C341522
18;U2;SOT-23-5;1;MIC5205-3.3YM5;C37970
19;U3;SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm;1;TP4056;C2763448
20;C7,C9;C_0805_2012Metric;2;330nF;C309049

## Commit log

2022-06-27 Initial version
    Modified version of RF24Audio minimal program with some changes to make it work with NRF24L01 mini module and ATMEGA328P-AU at 3.3V / 8MHz.
    RF24Audio config: Sample Rate 18000, Transmission speed 250kbps, Ten bit sampling
2022-06-27 PCB version v1.0
    Kicad Project with schematic and pcb files, includes BOM.
    Minor mistakes to be corrected in v1.1 including the audio pre-amp circuit and some component values
2022-06-28 Updated PCB version to v1.1
    Fixed some schematic error designs at audio amplifier circuit, modified NRF24 mini footprint to easier placement.
2022-06-30 Updated bill of materials v1.1
2023-05-30 Updated PCB files to v1.2
    Improved circuit board to v1.2 -
    Added a flexPCB connector on the edge of the board connected to the ICSP pins, making easier to program the ATMEGA328P.
    The battery terminals footprint is now only on one side of the board, preventing accidental short-circuit on the bottom side.
    Moved some components to allow more space for the LiPo battery.
    Changed the values of components C7,C9 R5,R6, adjusting the values for filtering the audio output.
2023-05-30 Updated PCB (v1.2)
    Added a flexPCB connector on the edge of the board connected to the ICSP pins, making easier to program the ATMEGA328P.
    The battery terminals footprint is now only on one side of the board, preventing accidental short-circuit on the bottom side.
    Moved some components to allow more space for the LiPo battery.
    Changed the values of components C7,C9 R5,R6, adjusting the values for filtering the audio output.
2023-05-30 Updated Arduino Code
    Set the Sampling rate of audio to 16000
2023-06-21 Updated Schematic PDF file
